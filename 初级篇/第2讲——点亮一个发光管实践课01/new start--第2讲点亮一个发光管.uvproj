# Keil uVision project new start--第2讲点亮一个发光管.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: new start--第2讲点亮一个发光管 +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: new start.c
